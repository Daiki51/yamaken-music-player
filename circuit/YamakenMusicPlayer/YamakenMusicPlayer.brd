# Repository Daiki51/yamaken-music-player

File README.md:

# YamakenMusicPlayer

「自動昼休み音楽プレイヤー (yamaken-music-player)」は毎日同じ時刻に音楽を再生するプレイヤーです。

GitHub: [https://github.com/Daiki51/yamaken-music-player](https://github.com/Daiki51/yamaken-music-player)

## 特徴
- 毎日同じ時刻に指定した時間(分)だけ音楽を再生
- 曲順は毎日シャッフル
- 音楽ファイルはSDカードから読み出し
- 手動での再生も対応
- NTPで時刻を同期しているため、時刻調整が不要
- IFTTTのサービスを利用し、音楽再生時にユーザーに通知可能
- Arduino IDEに対応したチップを使用しているため、振る舞いを簡単にカスタマイズ可

## ドキュメント

1. [再生する曲の変更]()
1. [制作方法]()
1. [ソフトウェアの書き込み方]()

## 回路図

詳細: [schematic.pdf](/circuit/YamakenMusicPlayer/schematic.pdf)

### A 電源回路部

### B 制御IC部

### C プレイヤーIC部

## 部品表

| 記号       | 品名                   | 個数 | 備考                                                |
|------------|------------------------|------|-----------------------------------------------------|
| U1         | NJM2396F33             | 1    | 定電圧リニアレギュレータ                              |
| U2         | AE-ESP-WROOM-02        | 1    | Wi-Fiモジュール (制御ICとして利用)                     |
| U3         | DFR0299 (DFPlayer Mini) | 1    | MP3モジュール                                        |
| J1         | MJ-179PH                | 1    | 2.1mm標準DCジャック                                 |
| J2         | AJ-1780                | 1    | 3.5mmステレオミニジャック                             |
| R1, R3, R4 | 10kΩ                   | 3    | 1/4W 炭素皮膜抵抗　表示「茶黒橙金」                    |
| R2         | 220Ω                   | 1    | 1/4W 炭素皮膜抵抗　表示「赤赤茶金」                    |
| R5         | 100Ω                   | 1    | 1/4W 炭素皮膜抵抗　表示「茶黒茶金」                    |
| C1         | 0.33μF                 | 1    | セラミックコンデンサ                                  |
| C2         | 22μF                   | 1    | 電解コンデンサ                                       |
| C3, C5, C7 | 0.1μF                  | 3    | セラミックコンデンサ                                  |
| C4, C6     | 10μF                   | 2    | セラミックコンデンサ                                 |
| S1           | DIPスイッチ            | 1    | ブートモード切り替えスイッチ                          |
| S2         | タクトスイッチ (赤)     | 1    | リセットボタン                                        |
| S3         | タクトスイッチ (白)     | 1    | 再生ボタン                                            |
| LED1       | 緑色LED                | 1    | 抵抗内蔵LED                                         |
| LED2       | 青色LED                | 1    | 抵抗内蔵LED                                         |
| JP1, JP2   | ピンヘッダ (3ピン)       | 2    | 2.54mmピッチ シングルライン                          |
|            | SH16K4B102L20KC        | 1    | 小型ボリューム 1kΩB                                  |
|            | ABS-15                | 1    | 小型ボリューム用ツマミ                                |

## 部品配置図

詳細: [board.pdf](/circuit/YamakenMusicPlayer/board.pdf)

## 依存ライブラリ

[DFPlayer - A Mini MP3 Player For Arduino](https://github.com/DFRobot/DFRobotDFPlayerMini)

[Arduino Client for MQTT (PubSubClient)](https://github.com/knolleary/pubsubclient)

[SerialCommand](https://github.com/kroimon/Arduino-SerialCommand)

[JLed - Advanced LED Library](https://github.com/jandelgado/jled)

[Switch library](https://github.com/avandalen/avdweb_Switch)

[Low-Pass-Filter](https://github.com/Billwilliams1952/Arduino-Cascadable-Low-Pass-Filter)

> 本プロジェクトのスケッチを動作させるためには、[Arduino Client for MQTT (PubSubClient)](https://github.com/knolleary/pubsubclient)と[SerialCommand](https://github.com/kroimon/Arduino-SerialCommand)の変更が必要です。

## ライセンス

[MIT](https://github.com/atom/atom/blob/master/LICENSE.md)

## EAGLE design circuit/YamakenMusicPlayer/YamakenMusicPlayer.brd

Parts:
C1: 0.33μF; C050-024X044
C2: 22μF; E2,5-7
C3, C5, C7: 0.1μF; C050-024X044
C4, C6: 10μF; C050-024X044
J1: MJ-179PH; DCJ0202
J2: PG203J
JP1: UART DOWNLOAD; 1X03
JP2: VOLUME_VR; 1X03
LED1: PLAYING_LED; LED5MM
LED2: ONLINE_LED; LED5MM
R1, R3, R4: 10KΩ; 0207/10
R2: 220Ω; 0207/10
R5: 100Ω; 0207/10
S1: BOOT_OPTION; DIP02YL
S2: RESET_BTN; B3F-10XX
S3: PLAY_BTN; B3F-10XX
U1: NJM2396F33; TO254P480X1000X1900-4P
U2: AE-ESP-WROOM-02
U3: DFPLAYERMINI

Connections:
+12V: C1.1, J1.1, U1.1 (VIN)
DAC_GND: J2.1, U3.GND_1 (DAC_GND)
DAC_R: J2.2, U3.DAC_R
GND: C1.2, C2.-, C3.2, C4.1, C5.1, C6.1, C7.1, J1.3, JP1.1, JP2.3, LED1.K (C), LED2.K (C), R4.1, R5.1, S1.4, S2.3, S3.3, U1.3 (GND), U2.P9 (GND), U2.P13 (GND), U2.P18 (GND), U3.GND_2
unnamed: R1.1, S2.1 (S), U2.P15 (RST), U2.P17 (IO16)
unnamed: J2.5, U3.DAC_L
unnamed: C3.1, R3.1, U2.P2 (EN)
unnamed: S1.1, U2.P8 (IO0)
unnamed: R4.2, U2.P6 (IO15)
unnamed: JP1.2, U2.P12 (TXD)
unnamed: JP1.3, U2.P11 (RXD)
unnamed: JP2.1, R2.1, R5.2
ONLINE_LED: LED2.A, U2.P5 (IO13)
PLAYER_RX: U2.P10 (IO4), U3.TX
PLAYER_TX: U2.P14 (IO5), U3.RX
PLAYING_LED: LED1.A, U2.P4 (IO12)
PLAY_BTN: S3.1 (S), U2.P3 (IO14)
V+: C2.+, C4.2, C5.2, C6.2, C7.2, R1.2, R2.2, R3.2, U1.2 (VOUT), U2.P1 (3V3), U3.VCC
VOLUME: JP2.2, U2.P16 (TOUT)

Notes on the sheet:
※抵抗内蔵LED
山田研究室
自動昼休み音楽プレイヤー
Designed by 16TE014 中禮 大貴
B) 制御IC部
A) 電源回路部
C) プレイヤーIC部

Board: 2 copper layers, 100.0 x 80.0 mm, 24 parts (3 on the bottom side), 19 nets.

## Code that names these connections

File src/YamakenMusicPlayer/YamakenMusicPlayer.ino (part):

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// 定数
//-------------------------------------
// ピン番号
const int8_t PLAYER_RX_PIN = 4;
const int8_t PLAYER_TX_PIN = 5;
const int PLAYING_LED_PIN = 12;
const int ONLINE_LED_PIN = 13;
const int PLAY_SW_PIN = 14;
const int VOLUME_PIN = A0;

// ボリュームセンサーのアナログ最大値
const int VOLUME_SENSOR_MAX = 1024;
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//-------------------------------------

// DFPlayerとの通信を担当するクラス
PlayerService playerService(PLAYER_RX_PIN, PLAYER_TX_PIN);

// 定期的な再生スケジューリングを管理するクラス
MusicScheduler musicScheduler;

// ボタンとLED
Switch playButton(PLAY_SW_PIN);
JLed playingLed(PLAYING_LED_PIN);
JLed onlineLed(ONLINE_LED_PIN);

// 音量関係
int volume = -1;
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}

float getRawVolume() {
  return fmaxf(fminf(((float)analogRead(VOLUME_PIN) - VOLUME_SENSOR_MIN) / (VOLUME_SENSOR_MAX - VOLUME_SENSOR_MIN), 1.0), 0.0);
}

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
## Commit log

2019-03-04 基板上に表記を追加
2019-03-04 回路図画像を追加
2019-03-04 画像を加工
2019-03-04 表記の修正
2019-03-04 Update schematic_c.png
    画像の修正
2019-03-04 U3の表記を追加
2019-03-05 ファイルの差し替え
2019-06-13 基板の修正
2019-06-17 MQTTを使用するように変更
2019-06-17 トップ画像を差し替え
2019-06-17 ピン配置図を移動
2019-06-17 依存ライブラリを自動でダウンロードするスクリプトを追加
2019-06-17 Wi-Fiを再接続する機能を実装
    また、設定をJSON形式で保存するように変更
2019-06-18 MQTTを再接続するように
